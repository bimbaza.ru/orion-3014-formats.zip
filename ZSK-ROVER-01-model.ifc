Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:49+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-ROVER-01
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-ROVER-01 Игровой элемент (Транспорт) «Космический вездеход»
In: Площадка
Description: Оборудование благоустройства. Игровой элемент (Транспорт) «Космический вездеход»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР)); Material: Панели HDPE, сталь с порошковым покрытием
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-ROVER-01; ModelReference: Игровой элемент (Транспорт) «Космический вездеход»; ProductionYear: 2026; ArticleNumber: ZSK-ROVER-01
ORION_Изделие - Артикул: ZSK-ROVER-01; Артикул прежний: SD-ROVER-01; Наименование: Игровой элемент (Транспорт) «Космический вездеход»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3.0 x 2.1 м; Зона безопасности: По запросу; Высота свободного падения: На уровне земли; Возраст: для детей от 2 до 5 лет; Материал: Панели HDPE, сталь с порошковым покрытием; Цена: 1 563 840 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3014; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Игровой элемент (Транспорт) «Космический вездеход»; ADSK_Марка: ZSK-ROVER-01; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Панели HDPE, сталь с порошковым покрытием; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3014
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 5 лет; ZSK_Зона_безопасности: По запросу; ZSK_Высота_свободного_падения: На уровне земли; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-ROVER-01
Qto_ORION - Длина: 3000 mm; Ширина: 2100 mm; Высота: 0 mm
